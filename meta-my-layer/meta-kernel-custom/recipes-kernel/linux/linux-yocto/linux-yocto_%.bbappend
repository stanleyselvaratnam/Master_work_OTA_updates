FILESEXTRAPATHS:prepend := "${THISDIR}/../files:"
SRC_URI += "file://0001-add-custom-printk.patch"
